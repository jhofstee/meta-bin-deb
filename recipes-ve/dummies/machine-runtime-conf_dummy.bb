# dummy, just to make parsing work
LICENSE = "CLOSED"
