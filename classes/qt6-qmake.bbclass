# dummy, to make parsing work.
SRC_URI := "file:///dev/null"
